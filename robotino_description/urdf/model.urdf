Commit message: robotino_vision now is reading parameters from a yaml file

File: robotino_description/urdf/model.urdf (robot description, URDF)
Before this commit: robot robotino, 8 links, 7 joints
Joints:
- joint laser_joint: origin xyz=-0.022 10 0.232 rpy=0 0 0 -> xyz=0.1 0 0 rpy=0 0 0
